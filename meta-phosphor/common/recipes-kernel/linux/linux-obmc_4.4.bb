KBRANCH ?= "dev-4.4"
LINUX_VERSION ?= "4.4"
SRCREV="${AUTOREV}"

require linux-obmc.inc
