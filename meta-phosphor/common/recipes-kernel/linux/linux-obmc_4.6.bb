KBRANCH ?= "dev-4.6"
LINUX_VERSION ?= "4.6"
SRCREV="44a5f06b4c1820add4cbbee494edf811a3076f20"

require linux-obmc.inc
