SRCREV ?= "7cb4972f7e9143702c1c80f9086db58e3e15bdf7"
SKELETON_URI ?= "git://github.com/tpilukechen/skeleton"
