SUMMARY = "Fox board wiring"
DESCRIPTION = "Board wiring information for the Fox system."
PR = "r1"

inherit config-in-skeleton
